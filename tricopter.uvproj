# Keil uVision project tricopter.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2103 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: tricopter +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x40000000 size 0x2000
  group Source Group 1
    ./: Startup.s declarations.h main.c STDIO.H iic_com_driver.c iic_com_driver.h LPC2103.h sensors_i2c.c sensors_i2c.h hal.h uart.c uart.h config.h algo.c spi.c spi.h pid.c pid.h dio.c dio.h nRF24L01_driver.c output.c led.c
